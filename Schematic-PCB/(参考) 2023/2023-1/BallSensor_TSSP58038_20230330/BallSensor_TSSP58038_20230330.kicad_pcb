# Repository nearfactory/2024-TOINIOT2

## KiCad design Schematic-PCB/(参考) 2023/2023-1/BallSensor_TSSP58038_20230330/BallSensor_TSSP58038_20230330.kicad_pcb

Parts:
C1: By-pass; C_0805_2012Metric
C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25: C; C_0603_1608Metric
D1: LED; LED_0603_1608Metric
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17: WS2812B
J1: Conn_01x20_Male; IDC-Header_2x10_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17: R; R_0603_1608Metric
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16: TSSP58038

Connections:
+5V: C1.1, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), D10.1 (VDD), D11.1 (VDD), D12.1 (VDD), D13.1 (VDD), D14.1 (VDD), D15.1 (VDD), D16.1 (VDD), D17.1 (VDD), J1.18, J1.19, R1.1, U1.3 (Vs), U2.3 (Vs), U3.3 (Vs), U4.3 (Vs), U5.3 (Vs), U6.3 (Vs), U7.3 (Vs), U8.3 (Vs), U9.3 (Vs), U10.3 (Vs), U11.3 (Vs), U12.3 (Vs), U13.3 (Vs), U14.3 (Vs), U15.3 (Vs), U16.3 (Vs); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, D1.1 (K), D2.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), D10.3 (VSS), D11.3 (VSS), D12.3 (VSS), D13.3 (VSS), D14.3 (VSS), D15.3 (VSS), D16.3 (VSS), D17.3 (VSS), J1.20, U1.2 (GND), U2.2 (GND), U3.2 (GND), U4.2 (GND), U5.2 (GND), U6.2 (GND), U7.2 (GND), U8.2 (GND), U9.2 (GND), U10.2 (GND), U11.2 (GND), U12.2 (GND), U13.2 (GND), U14.2 (GND), U15.2 (GND), U16.2 (GND); also elsewhere on the board
unnamed 2: D1.2 (A), R1.2; also elsewhere on the board
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D8.2 (DOUT), D9.4 (DIN)
unnamed: D9.2 (DOUT), D10.4 (DIN)
unnamed: D10.2 (DOUT), D11.4 (DIN)
unnamed: D11.2 (DOUT), D12.4 (DIN)
unnamed: D12.2 (DOUT), D13.4 (DIN)
unnamed: D13.2 (DOUT), D14.4 (DIN)
unnamed: D14.2 (DOUT), D15.4 (DIN)
unnamed: D15.2 (DOUT), D16.4 (DIN)
unnamed: D16.2 (DOUT), D17.4 (DIN)
sig1: R2.1, U1.1 (OUT)
sig1-LPF: C2.1, J1.1, R2.2
sig2: R3.1, U2.1 (OUT)
sig2-LPF: C3.1, J1.2, R3.2
sig3: R4.1, U3.1 (OUT)
sig3-LPF: C4.1, J1.3, R4.2
sig4: R5.1, U4.1 (OUT)
sig4-LPF: C5.1, J1.4, R5.2
sig5: R6.1, U5.1 (OUT)
sig5-LPF: C6.1, J1.5, R6.2
sig6: R7.1, U6.1 (OUT)
sig6-LPF: C7.1, J1.6, R7.2
sig7: R8.1, U7.1 (OUT)
sig7-LPF: C8.1, J1.7, R8.2
sig8: R9.1, U8.1 (OUT)
sig8-LPF: C9.1, J1.8, R9.2
sig9: R10.1, U9.1 (OUT)
sig9-LPF: C10.1, J1.9, R10.2
sig10: R11.1, U10.1 (OUT)
sig10-LPF: C11.1, J1.10, R11.2
sig11: R12.1, U11.1 (OUT)
sig11-LPF: C12.1, J1.11, R12.2
sig12: R13.1, U12.1 (OUT)
sig12-LPF: C13.1, J1.12, R13.2
sig13: R14.1, U13.1 (OUT)
sig13-LPF: C14.1, J1.13, R14.2
sig14: R15.1, U14.1 (OUT)
sig14-LPF: C15.1, J1.14, R15.2
sig15: R16.1, U15.1 (OUT)
sig15-LPF: C16.1, J1.15, R16.2
sig16: R17.1, U16.1 (OUT)
sig16-LPF: C17.1, J1.16, R17.2
sig_NeoPixel: D2.4 (DIN), J1.17

Notes on the sheet:
ローパスフィルタ 39KΩ 0.33µF

Board: 4 copper layers, 100.0 x 100.0 mm, 76 parts (49 on the bottom side), 51 nets.

Other parts of the board:
BYPS: By-pass; C_0805_2012Metric
PWR: LED; LED_0603_1608Metric

Their connections:
+5V: BYPS.1; also elsewhere on the board
GND: BYPS.2, PWR.1 (K); also elsewhere on the board
unnamed 2: PWR.2 (A); also elsewhere on the board

File Schematic-PCB/(参考) 2023/2023-1/BallSensor_TSSP58038_20230330/jlcpcb/production_files/BOM-BallSensor_TSSP58038_20230330.csv:

Comment,Designator,Footprint,LCSC
TSSP58038,"U1,U10,U11,U12,U13,U14,U15,U16,U2,U3,U4,U5,U6,U7,U8,U9",TSSP58038,C144844
C,"C18,C19,C20,C21,C22,C23,C24,C25",C_0603_1608Metric,C14663
C,"C10,C11,C12,C13,C14,C15,C16,C17,C2,C3,C4,C5,C6,C7,C8,C9",C_0603_1608Metric,C1615
~,"D10,D11,D12,D13,D14,D15,D16,D17,D2,D3,D4,D5,D6,D7,D8,D9",WS2812B,C2761795
R,"R1,R10,R11,R12,R13,R14,R15,R16,R17,R2,R3,R4,R5,R6,R7,R8,R9",R_0603_1608Metric,C4275
Conn_01x20_Male,J1,IDC-Header_2x10_P2.54mm_Vertical,

## KiCad design Schematic-PCB/(参考) 2023/2023-1/KickerAdjust_20230828/KickerAdjust_20230828.kicad_pcb

Board: 2 copper layers, 71.4 x 35.5 mm, 7 parts (1 on the bottom side), 6 nets.

Parts:
C1, C2: C; CP_Radial_D12.5mm_P5.00mm
J1: Conn_01x03_Pin; JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal
J2: Conn_01x02_Pin; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
Q1: NMOS; TO-252-3_TabPin2
U1: PhotoCoupler; DIP-4_W7.62mm_Socket
U2: XL6009

Connections:
+5V: J1.2, U2.1 (IN+)
+36V: C1.1, C2.1, J2.2, U2.3 (OUT+)
GND: C1.2, C2.2, J1.3, Q1.3 (S), U1.2 (Cathode), U2.2 (IN-), U2.4 (OUT-)
unnamed: Q1.1 (G), U1.3 (Drain), U1.4 (Drain)
Sig: J1.1, U1.1 (Anode)
Solenoid: J2.1, Q1.2 (D)

## KiCad design Schematic-PCB/(参考) 2023/2023-1/LineSensor_20230418/LineSensor_20230418.kicad_pcb

Board: 2 copper layers, 202.0 x 166.0 mm, 93 parts (2 on the bottom side), 71 nets.

Parts:
C1: C; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22: LED; OSWT3166B
J1: Conn_01x26_Pin; IDC-Header_2x13_P2.54mm_Vertical
J2: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q21, Q22: NJL7502L
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23: TSR-C3305
R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46: R; R_0603_1608Metric

Connections:
GND: C1.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), J1.26, J2.2, R1.1 (CW), R2.1 (CW), R3.1 (CW), R4.1 (CW), R5.1 (CW), R6.1 (CW), R7.1 (CW), R8.1 (CW), R9.1 (CW), R10.1 (CW), R11.1 (CW), R12.1 (CW), R13.1 (CW), R14.1 (CW), R15.1 (CW), R16.1 (CW), R17.1 (CW), R18.1 (CW), R19.1 (CW), R20.1 (CW), R21.1 (CW), R22.1 (CW), R24.1
unnamed: D1.2 (A), R25.2
unnamed: D2.2 (A), R26.2
unnamed: D3.2 (A), R27.2
unnamed: D4.2 (A), R28.2
unnamed: D5.2 (A), R29.2
unnamed: D6.2 (A), R30.2
unnamed: D7.2 (A), R31.2
unnamed: D8.2 (A), R32.2
unnamed: D9.2 (A), R33.2
unnamed: D10.2 (A), R34.2
unnamed: D11.2 (A), R35.2
unnamed: D12.2 (A), R36.2
unnamed: D13.2 (A), R37.2
unnamed: D14.2 (A), R38.2
unnamed: D15.2 (A), R39.2
unnamed: D16.2 (A), R40.2
unnamed: D17.2 (A), R41.2
unnamed: D18.2 (A), R42.2
unnamed: D19.2 (A), R43.2
unnamed: D20.2 (A), R44.2
unnamed: D21.2 (A), R45.2
unnamed: D22.2 (A), R46.2
unnamed: Q1.2 (Emitter), R1.2 (WIPER)
unnamed: Q2.2 (Emitter), R2.2 (WIPER)
unnamed: Q3.2 (Emitter), R3.2 (WIPER)
unnamed: Q4.2 (Emitter), R4.2 (WIPER)
unnamed: Q5.2 (Emitter), R5.2 (WIPER)
unnamed: Q6.2 (Emitter), R6.2 (WIPER)
unnamed: Q7.2 (Emitter), R7.2 (WIPER)
unnamed: Q8.2 (Emitter), R8.2 (WIPER)
unnamed: Q9.2 (Emitter), R9.2 (WIPER)
unnamed: Q10.2 (Emitter), R10.2 (WIPER)
unnamed: Q11.2 (Emitter), R11.2 (WIPER)
unnamed: Q12.2 (Emitter), R12.2 (WIPER)
unnamed: Q13.2 (Emitter), R13.2 (WIPER)
unnamed: Q14.2 (Emitter), R14.2 (WIPER)
unnamed: Q15.2 (Emitter), R15.2 (WIPER)
unnamed: Q16.2 (Emitter), R16.2 (WIPER)
unnamed: Q17.2 (Emitter), R17.2 (WIPER)
unnamed: Q18.2 (Emitter), R18.2 (WIPER)
unnamed: Q19.2 (Emitter), R19.2 (WIPER)
unnamed: Q20.2 (Emitter), R20.2 (WIPER)
unnamed: Q21.2 (Emitter), R21.2 (WIPER)
unnamed: Q22.2 (Emitter), R22.2 (WIPER)
unnamed: R23.3 (CCW), R24.2
unnamed: R23.1 (CW), R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, R33.1, R34.1, R35.1, R36.1, R37.1, R38.1, R39.1, R40.1, R41.1, R42.1, R43.1, R44.1, R45.1, R46.1
VIN: C1.1, J1.24, J1.25, J2.3, Q1.1 (Corrector), Q2.1 (Corrector), Q3.1 (Corrector), Q4.1 (Corrector), Q5.1 (Corrector), Q6.1 (Corrector), Q7.1 (Corrector), Q8.1 (Corrector), Q9.1 (Corrector), Q10.1 (Corrector), Q11.1 (Corrector), Q12.1 (Corrector), Q13.1 (Corrector), Q14.1 (Corrector), Q15.1 (Corrector), Q16.1 (Corrector), Q17.1 (Corrector), Q18.1 (Corrector), Q19.1 (Corrector), Q20.1 (Corrector), Q21.1 (Corrector), Q22.1 (Corrector), R23.2 (WIPER)
sig1: J1.1, R1.3 (CCW)
sig2: J1.2, R2.3 (CCW)
sig3: J1.3, R3.3 (CCW)
sig4: J1.4, R4.3 (CCW)
sig5: J1.5, R5.3 (CCW)
sig6: J1.6, R6.3 (CCW)
sig7: J1.7, R7.3 (CCW)
sig8: J1.8, R8.3 (CCW)
sig9: J1.9, R9.3 (CCW)
sig10: J1.10, R10.3 (CCW)
sig11: J1.11, R11.3 (CCW)
sig12: J1.12, R12.3 (CCW)
sig13: J1.13, R13.3 (CCW)
sig14: J1.14, R14.3 (CCW)
sig15: J1.15, R15.3 (CCW)
sig16: J1.16, R16.3 (CCW)
sig17: J1.17, R17.3 (CCW)
sig18: J1.18, R18.3 (CCW)
sig19: J1.19, R19.3 (CCW)
sig20: J1.20, R20.3 (CCW)
sig21: J1.21, R21.3 (CCW)
sig22: J1.22, R22.3 (CCW)
sig_BALL-Kicker: J1.23, J2.1

## KiCad design Schematic-PCB/(参考) 2023/2023-1/MainBoard_ATMega2560Pro_20230629/MainBoard_ATMega2560Pro_20230629.kicad_pcb

Board: 2 copper layers, 70.0 x 103.0 mm, 39 parts (9 on the bottom side), 83 nets.

Parts:
BZ1: Buzzer; PKM13EPYH4000-A0
C1: C; C_0805_2012Metric
D1, D2, D3, D4: LED; LED_0603_1608Metric
J1: Conn_01x10_Pin; IDC-Header_2x05_P2.54mm_Vertical
J2, J4: Conn_01x08_Male; JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
J3: Conn_01x04_Female; PinSocket_1x04_P2.54mm_Vertical
J5: Conn_01x02_Male; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
J6: Conn_01x20_Male; IDC-Header_2x10_P2.54mm_Vertical
J7: Conn_01x26_Male; IDC-Header_2x13_P2.54mm_Vertical
J8: Conn_01x03_Pin; JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal
JP1, JP2, JP3, JP4, JP5, JP6: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R1, R2, R3, R4: 330; R_0805_2012Metric
R5, R7, R9, R11, R13: 1K; R_0805_2012Metric
R6, R8, R10, R12: 10K; R_0805_2012Metric
SW1, SW2, SW3: SW_DPST_x2; TVBP06-B043C
SW4: SW_DPDT_x2; SS12D01G4
U1: ATMEGA2560_pro; MODULE_MEGA_PRO_EMBED_CH340G___ATMEGA2560
U2: BNO055

Connections:
GND: BZ1.2 (+), C1.2, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), J1.6, J2.8, J3.2, J4.8, J5.2, J6.20, J7.26, J8.3, R6.1, R8.1, R10.1, R12.1, R13.2, U1.GND_1 (GND), U1.GND_2 (GND), U1.GND_3 (GND), U2.2 (GND), U2.7 (GND)
MISO: JP4.2 (B), U1.D50
MOSI: JP1.2 (B), U1.D51
unnamed: D1.1 (K), R1.2
unnamed: D2.1 (K), R2.2
unnamed: D3.1 (K), R3.2
unnamed: D4.1 (K), R4.2
unnamed: J1.1, JP4.1 (A)
unnamed: J1.3, JP2.1 (A)
unnamed: J1.4, JP1.1 (A)
unnamed: J1.5, JP5.1 (A)
unnamed: J1.7, JP3.1 (A)
unnamed: J1.9, JP6.1 (A)
unnamed: R5.1, R6.2, SW1.2 (B)
unnamed: R7.1, R8.2, SW2.2 (B)
unnamed: R9.1, R10.2, SW3.2 (B)
unnamed: R11.1, R12.2, SW4.3 (C)
PWM_Buzzer: BZ1.1 (-), U1.D6
PWM_M1: J2.3, U1.D2
PWM_M2: J2.6, U1.D3
PWM_M3: J4.3, U1.D4
PWM_M4: J4.6, U1.D5
SCK: JP2.2 (B), U1.D52
SCL: J3.3, JP5.2 (B), U1.D21, U2.4 (SCL/R)
SDA: J3.4, JP6.2 (B), U1.D20, U2.3 (SDA/T)
SS: JP3.2 (B), U1.D53
Sig1_BALL: J6.1, U1.A0
Sig1_LINE: J7.1, U1.D26
Sig2_BALL: J6.2, U1.A1
Sig2_LINE: J7.2, U1.D27
Sig3_BALL: J6.3, U1.A2
Sig3_LINE: J7.3, U1.D28
Sig4_BALL: J6.4, U1.A3
Sig4_LINE: J7.4, U1.D29
Sig5_BALL: J6.5, U1.A4
Sig5_LINE: J7.5, U1.D30
Sig6_BALL: J6.6, U1.A5
Sig6_LINE: J7.6, U1.D31
Sig7_BALL: J6.7, U1.A6
Sig7_LINE: J7.7, U1.D32
Sig8_BALL: J6.8, U1.A7
Sig8_LINE: J7.8, U1.D33
Sig9_BALL: J6.9, U1.A8
Sig9_LINE: J7.9, U1.D34
Sig10_BALL: J6.10, U1.A9
Sig10_LINE: J7.10, U1.D35
Sig11_BALL: J6.11, U1.A10
Sig11_LINE: J7.11, U1.D36
Sig12_BALL: J6.12, U1.A11
Sig12_LINE: J7.12, U1.D37
Sig13_BALL: J6.13, U1.A12
Sig13_LINE: J7.13, U1.D38
Sig14_BALL: J6.14, U1.A13
Sig14_LINE: J7.14, U1.D39
Sig15_BALL: J6.15, U1.A14
Sig15_LINE: J7.15, U1.D40
Sig16_BALL: J6.16, U1.A15
Sig16_LINE: J7.16, U1.D41
Sig17_LINE: J7.17, U1.D42
Sig18_LINE: J7.18, U1.D43
Sig19_LINE: J7.19, U1.D44
Sig20_LINE: J7.20, U1.D45
Sig21_LINE: J7.21, U1.D46
Sig22_LINE: J7.22, U1.D47
Sig23_BALL-Kicker: J7.23, U1.D49
Sig_BTN1: R5.2, U1.D7
Sig_BTN2: R7.2, U1.D8
Sig_BTN3: R9.2, U1.D9
Sig_Kicker: J8.1, R13.1, U1.D12
Sig_LED1: R2.1, U1.D13
Sig_LED2: R3.1, U1.D14
Sig_LED3: R4.1, U1.D15
Sig_LEVER: R11.2, U1.D10
Sig_M1-1: J2.1, U1.D16
Sig_M1-2: J2.2, U1.D17
Sig_M2-1: J2.4, U1.D18
Sig_M2-2: J2.5, U1.D19
Sig_M3-1: J4.1, U1.D22
Sig_M3-2: J4.2, U1.D23
Sig_M4-1: J4.4, U1.D24
Sig_M4-2: J4.5, U1.D25
Sig_NeoPixel: J6.17, U1.D11
VIN: C1.1, J1.2, J2.7, J3.1, J4.7, J5.1, J6.18, J6.19, J7.24, J7.25, J8.2, R1.1, SW1.1 (A), SW2.1 (A), SW3.1 (A), SW4.1 (A), SW4.2 (B), U1.VIN_1 (VIN), U1.VIN_2 (VIN), U2.1 (VIN)

## KiCad design Schematic-PCB/(参考) 2023/2023-1/MotorDriver_TB6612FNG_20230704/MotorDriver_TB6612FNG_20230704.kicad_pcb

Parts:
C1, C2: C; C_1206_3216Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10: LED; LED_0603_1608Metric
J1, J2, J3, J5, J6, J7: Conn_01x02_Male; JST_VH_B2PS-VH_1x02_P3.96mm_Horizontal
J4, J8: Conn_01x08_Male; JST_XH_B8B-XH-A_1x08_P2.50mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10: 330; R_0805_2012Metric
U1, U2: TB6612FNG

Connections:
GND: C1.2, C2.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), J1.2, J4.8, J5.2, J8.8, U1.1 (GND), U1.8 (GND), U1.9 (GND), U2.1 (GND), U2.8 (GND), U2.9 (GND)
LogicVin: J4.7, R1.1, U1.2 (VCC), U1.13 (STBY)
LogicVin-2: J8.7, R6.1, U2.2 (VCC), U2.13 (STBY)
M1_IN1: J4.1, R2.1, U1.14 (AIN2)
M1_IN2: J4.2, R3.1, U1.15 (AIN1)
M1_OUT1: J2.1, U1.3 (AO1)
M1_OUT2: J2.2, U1.4 (AO2)
M1_PWM: J4.3, U1.16 (PWMA)
M2_IN1: J4.4, R4.1, U1.11 (BIN2)
M2_IN2: J4.5, R5.1, U1.12 (BIN1)
M2_OUT1: J3.1, U1.6 (BO2)
M2_OUT2: J3.2, U1.5 (BO1)
M2_PWM: J4.6, U1.10 (PWMB)
M3_IN1: J8.1, R7.1, U2.14 (AIN2)
M3_IN2: J8.2, R8.1, U2.15 (AIN1)
M3_OUT1: J6.1, U2.3 (AO1)
M3_OUT2: J6.2, U2.4 (AO2)
M3_PWM: J8.3, U2.16 (PWMA)
M4_IN1: J8.4, R9.1, U2.11 (BIN2)
M4_IN2: J8.5, R10.1, U2.12 (BIN1)
M4_OUT1: J7.1, U2.6 (BO2)
M4_OUT2: J7.2, U2.5 (BO1)
M4_PWM: J8.6, U2.10 (PWMB)
MotorVin: C1.1, J1.1, U1.7 (VMOT)
MotorVin-2: C2.1, J5.1, U2.7 (VMOT)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: D6.2 (A), R6.2
unnamed: D7.2 (A), R7.2
unnamed: D8.2 (A), R8.2
unnamed: D9.2 (A), R9.2
unnamed: D10.2 (A), R10.2
