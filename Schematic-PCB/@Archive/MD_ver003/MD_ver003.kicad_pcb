# Repository nearfactory/2024-TOINIOT2

## KiCad design Schematic-PCB/@Archive/MD_ver003/MD_ver003.kicad_pcb

Parts:
C1, C9, C11, C13: 22n; C_0603_1608Metric
C2, C10, C12, C14: 220n; C_0603_1608Metric
C3, C4: 4.7u; C_0603_1608Metric
C5: 50u; C_0603_1608Metric
C7, C8: 0.1u; C_0603_1608Metric
D1: PWR; LED_0805_2012Metric
J1: Conn_01x05_Pin; PinSocket_1x05_P2.54mm_Horizontal
J2: Conn_01x04_Pin; JST_XH_S4B-XH-A-1_1x04_P2.50mm_Horizontal
J3, J4, J5, J6: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J7: Conn_01x02_Pin; XT30U-M
J8: Conn_main; TE_1-84953-5_1x15-1MP_P1.0mm_Horizontal
Q1, Q2: BSS138; SOT-23
R1: 330; R_0603_1608Metric
R3, R9, R13, R17, R20, R21, R22, R23: 10k; R_0603_1608Metric
R4, R8, R12, R16: 2.49k; R_0603_1608Metric
R6, R10, R14, R18: NP; R_0603_1608Metric; not fitted
R7, R11, R15, R19: 20k; R_0603_1608Metric
U1, U2, U3, U4: HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm

Connections:
+5V: J2.1, R21.1, R23.1
EN-1: J8.7, U1.1 (EN)
EN-2: J8.9, U2.1 (EN)
EN-3: J8.11, U3.1 (EN)
EN-4: J8.13, U4.1 (EN)
GND: C3.2, C4.2, C5.2, C7.2, C8.2, D1.1 (K), J1.3, J2.2, J7.2, J8.15, R4.2, R6.2, R7.2, R8.2, R10.2, R11.2, R12.2, R14.2, R15.2, R16.2, R18.2, R19.2, U1.9 (PGND), U1.15 (GND), U1.16 (PMODE), U1.17 (GND), U2.9 (PGND), U2.15 (GND), U2.16 (PMODE), U2.17 (GND), U3.9 (PGND), U3.15 (GND), U3.16 (PMODE), U3.17 (GND), U4.9 (PGND), U4.15 (GND), U4.16 (PMODE), U4.17 (GND)
IMODE-1: R7.1, U1.7 (IMODE)
IMODE-2: R11.1, U2.7 (IMODE)
IMODE-3: R15.1, U3.7 (IMODE)
IMODE-4: R19.1, U4.7 (IMODE)
KickerSignal-main: J1.2, J8.5
Line-Main=RX_3.3V: J8.2, Q1.2 (S), R20.1
Line-Main=RX_5V: J2.4, Q1.3 (D), R21.2
Line-Main=TX_3.3V: J8.1, Q2.2 (S), R22.1
Line-Main=TX_5V: J2.3, Q2.3 (D), R23.2
unnamed: D1.2 (A), R1.2
unnamed: C1.2, U1.13 (CPH)
unnamed: C1.1, U1.14 (CPL)
unnamed: R4.1, U1.6 (IPROPI)
unnamed: C2.1, U1.12 (VCP)
unnamed: C9.2, U2.13 (CPH)
unnamed: C9.1, U2.14 (CPL)
unnamed: R8.1, U2.6 (IPROPI)
unnamed: C10.1, U2.12 (VCP)
unnamed: C11.2, U3.13 (CPH)
unnamed: C11.1, U3.14 (CPL)
unnamed: R12.1, U3.6 (IPROPI)
unnamed: C12.1, U3.12 (VCP)
unnamed: C13.2, U4.13 (CPH)
unnamed: C13.1, U4.14 (CPL)
unnamed: R16.1, U4.6 (IPROPI)
unnamed: C14.1, U4.12 (VCP)
OUT1-1: J3.2, U1.8 (OUT1)
OUT1-2: J4.2, U2.8 (OUT1)
OUT1-3: J5.2, U3.8 (OUT1)
OUT1-4: J6.2, U4.8 (OUT1)
OUT2-1: J3.1, U1.10 (OUT2)
OUT2-2: J4.1, U2.10 (OUT2)
OUT2-3: J5.1, U3.10 (OUT2)
OUT2-4: J6.1, U4.10 (OUT2)
PH-1: J8.8, U1.2 (PH)
PH-2: J8.10, U2.2 (PH)
PH-3: J8.12, U3.2 (PH)
PH-4: J8.14, U4.2 (PH)
SLEEP-1: J1.4, J8.3, Q1.1 (G), Q2.1 (G), R1.1, R3.1, R9.1, R13.1, R17.1, R20.2, R22.2, U1.3 (SLEEP), U2.3 (SLEEP), U3.3 (SLEEP), U4.3 (SLEEP)
VCC: C2.2, C3.1, C4.1, C5.1, C7.1, C8.1, C10.2, C12.2, C14.2, J7.1, U1.11 (VM), U2.11 (VM), U3.11 (VM), U4.11 (VM)
VREF-1: R3.2, R6.1, U1.5 (VREF)
VREF-2: R9.2, R10.1, U2.5 (VREF)
VREF-3: R13.2, R14.1, U3.5 (VREF)
VREF-4: R17.2, R18.1, U4.5 (VREF)
ball01k: J1.5, J8.4
ball02k: J1.1, J8.6

Notes on the sheet:
MD3
LEVEL CONVERT
HIGH
TO MOTOR
TO LINE
TO KICKER
POWER
MD2
MD4
LOW
TO MAIN
MD1

Board: 2 copper layers, 100.5 x 56.4 mm, 49 parts (2 on the bottom side), 52 nets.

## KiCad design Schematic-PCB/@Archive/Main_ver001/Main_ver001.kicad_pcb

Parts:
C1, C2: C; C_0805_2012Metric
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18: 0.33uF; C_0603_1608Metric
C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34: 0.1uF; C_0603_1608Metric
D1: PWR-5; LED_0805_2012Metric
D2: PWR-3.3; LED_0805_2012Metric
D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D19: D_Small; D_A-405_P7.62mm_Horizontal
J1: Conn_01x10_Pin; JST_XH_B10B-XH-A_1x10_P2.50mm_Vertical
J2: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J3: Conn_01x15_Pin; 1.0K-FX-15PWB
J4: Conn_02x05_Odd_Even; IDC-Header_2x05_P2.54mm_Vertical
J5: Conn_01x04_Pin; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
JP1, JP3, JP5, JP7: Jumper_2_Small_Bridged; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
JP6, JP8: Jumper_2_Small_Open; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
R1, R2: 330; R_0603_1608Metric
R3, R4: 1K; R_0603_1608Metric
R5: 10K; R_0603_1608Metric
R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21: 39K; R_0603_1608Metric
U1: DEV-16771; MODULE_DEV-16771; PARTREV 4.1; DigiKey_Part_Number 1568-DEV-16771-ND
U2: XIAO ESP32C3
U3: BNO055
U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19: TSSP58038; Vishay_MINICAST-3Pin

Connections:
+3.3V: C2.1, J1.1, J2.2, J3.2, J5.3, R2.1, R3.1, R4.1, R5.1, U3.1 (VIN), U4.3 (Vs), U5.3 (Vs), U6.3 (Vs), U7.3 (Vs), U8.3 (Vs), U9.3 (Vs), U10.3 (Vs), U11.3 (Vs), U12.3 (Vs), U13.3 (Vs), U14.3 (Vs), U15.3 (Vs), U16.3 (Vs), U17.3 (Vs), U18.3 (Vs), U19.3 (Vs)
+5V: C1.1, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), D10.1 (VDD), D11.1 (VDD), D12.1 (VDD), D13.1 (VDD), D14.1 (VDD), D15.1 (VDD), D16.1 (VDD), D17.1 (VDD), D18.1 (VDD), D19.2 (A), J2.1, J4.2, R1.1, U1.VIN
BUZZER: J1.10, U1.33 (MCLK2)
Cam-MISO_RX: J4.1, JP5.2 (B), JP6.2 (B); also elsewhere on the board
Cam-MOSI_TX: J4.4, JP7.2 (B), JP8.2 (B); also elsewhere on the board
Cam-RX: JP6.1 (A), U1.35 (TX8); also elsewhere on the board
Cam-TX: JP8.1 (A), U1.34 (RX8); also elsewhere on the board
Cam_SS: JP3.1 (A), U1.10 (CS1); also elsewhere on the board
EN-1: J3.15, U1.29 (TX7)
EN-2: J3.13, U1.9 (OUT1C)
EN-3: J3.11, U1.5 (IN2)
EN-4: J3.9, U1.3 (LRCLK2)
EN-D: J5.2, U2.4 (A3_D3)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, D1.1 (K), D2.1 (K), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), D10.3 (VSS), D11.3 (VSS), D12.3 (VSS), D13.3 (VSS), D14.3 (VSS), D15.3 (VSS), D16.3 (VSS), D17.3 (VSS), D18.3 (VSS), J1.2, J2.3, J3.1, J4.6, J5.4, U1.GND1 (GND), U1.GND2 (GND), U1.GND3 (GND), U1.GND4 (GND), U1.GND5 (GND), U1.USB_GND1 (USB_GND), U1.USB_GND2 (USB_GND), U2.13 (GND), U3.2 (GND), U3.7 (GND), U4.2 (GND), U5.2 (GND), U6.2 (GND), U7.2 (GND), U8.2 (GND), U9.2 (GND), U10.2 (GND), U11.2 (GND), U12.2 (GND), U13.2 (GND), U14.2 (GND), U15.2 (GND), U16.2 (GND), U17.2 (GND), U18.2 (GND), U19.2 (GND); also elsewhere on the board
KickerSignal: J1.7, J3.6, U1.32 (OUT1B)
Line-RX: J3.3, U1.1 (TX1)
Line-TX: J3.4, U1.0 (RX1)
MISO: JP5.1 (A), U1.12 (MISO); also elsewhere on the board
MOSI: JP7.1 (A), U1.11 (MOSI); also elsewhere on the board
Main-RX2: U1.7 (RX2), U2.7 (TX_D6)
Main-TX2: U1.8 (TX2), U2.8 (RX_D7)
NeoPixel_PWM: D3.4 (DIN), U2.11 (MOSI_D10)
unnamed 22: D1.2 (A), R1.2; also elsewhere on the board
unnamed 23: D2.2 (A), R2.2; also elsewhere on the board
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D8.2 (DOUT), D9.4 (DIN)
unnamed: D9.2 (DOUT), D10.4 (DIN)
unnamed: D10.2 (DOUT), D11.4 (DIN)
unnamed: D11.2 (DOUT), D12.4 (DIN)
unnamed: D12.2 (DOUT), D13.4 (DIN)
unnamed: D13.2 (DOUT), D14.4 (DIN)
unnamed: D14.2 (DOUT), D15.4 (DIN)
unnamed: D15.2 (DOUT), D16.4 (DIN)
unnamed: D16.2 (DOUT), D17.4 (DIN)
unnamed: D17.2 (DOUT), D18.4 (DIN)
unnamed: D19.1 (K), U2.14 (5V)
unnamed 40: J4.3, JP1.2 (B); also elsewhere on the board
unnamed 41: J4.7, JP3.2 (B); also elsewhere on the board
unnamed: R5.2, U2.9 (SCK_D8)
unnamed: R6.1, U4.1 (OUT)
unnamed: R7.1, U5.1 (OUT)
unnamed: R8.1, U6.1 (OUT)
unnamed: R9.1, U7.1 (OUT)
unnamed: R10.1, U8.1 (OUT)
unnamed: R11.1, U9.1 (OUT)
unnamed: R12.1, U10.1 (OUT)
unnamed: R13.1, U11.1 (OUT)
unnamed: R14.1, U12.1 (OUT)
unnamed: R15.1, U13.1 (OUT)
unnamed: R16.1, U14.1 (OUT)
unnamed: R17.1, U15.1 (OUT)
unnamed: R18.1, U16.1 (OUT)
unnamed: R19.1, U17.1 (OUT)
unnamed: R20.1, U18.1 (OUT)
unnamed: R21.1, U19.1 (OUT)
PH-1: J3.14, U1.28 (RX7)
PH-2: J3.12, U1.6 (OUT1D)
PH-3: J3.10, U1.4 (BCLK2)
PH-4: J3.8, U1.2 (OUT2)
PH-D: J5.1, U2.3 (A2_D2)
SCK: JP1.1 (A), U1.13 (SCK); also elsewhere on the board
SCL: J1.9, R4.2, U1.24 (A10), U2.6 (SCL_D5), U3.4 (SCL/R)
SDA: J1.8, R3.2, U1.25 (A11), U2.5 (SDA_D4), U3.3 (SDA/T)
SW-TAC-1: J1.3, U1.36 (CS2)
SW-TAC-2: J1.4, U1.37 (CS3)
SW-TAC-3: J1.5, U1.31 (CTX3)
SW-TAC-4: J1.6, U1.30 (CRX3)
ball01: C3.1, R6.2, U1.14 (A0)
ball01k: J3.7, U2.1 (A0_D0)
ball02: C4.1, R7.2, U1.15 (A1)
ball02k: J3.5, U2.2 (A1_D1)
ball03: C5.1, R8.2, U1.16 (A2)
ball04: C6.1, R9.2, U1.17 (A3)
ball05: C7.1, R10.2, U1.18 (A4)
ball06: C8.1, R11.2, U1.19 (A5)
ball07: C9.1, R12.2, U1.20 (A6)
ball08: C10.1, R13.2, U1.21 (A7)
ball09: C11.1, R14.2, U1.22 (A8)
ball10: C12.1, R15.2, U1.23 (A9)
ball11: C13.1, R16.2, U1.26 (A12)
ball12: C14.1, R17.2, U1.27 (A13)
ball13: C15.1, R18.2, U1.38 (A14)
ball14: C16.1, R19.2, U1.39 (A15)
ball15: C17.1, R20.2, U1.40 (A16)
ball16: C18.1, R21.2, U1.41 (A17)

Notes on the sheet:
信号レベル SPI | 3.3V I2C | 5.0V-PULLUP UART | 3.3V
USB給電と 外部給電の 衝突回避用の ダイオード追加済
D6(pin7)は基本使用しない D9(pin10)はスイッチ入力に使用する
使用前には必ず開発ボード裏の VIN-VUSBジャンパをカットすること USBケーブルとの電源の混合が起き Teensyが燃えるため絶対に!!!!!
TO UI
UART
NEOPIXEL
POWER
BALL-SENSOR
BNO055
LED
Camera
SUB
MPU
DRIBBLER
TO MD

Board: 2 copper layers, 115.0 x 115.0 mm, 104 parts (59 on the bottom side), 89 nets.

Other parts of the board:
3.3V: PWR-3.3; LED_0805_2012Metric
5V: PWR-5; LED_0805_2012Metric
MISO: Jumper_2_Small_Bridged; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
MOSI: Jumper_2_Small_Bridged; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
RX: Jumper_2_Small_Open; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
SCK: Jumper_2_Small_Bridged; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
SS: Jumper_2_Small_Bridged; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
TX: Jumper_2_Small_Open; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm

Their connections:
Cam-MISO_RX: MISO.2 (B), RX.2 (B); also elsewhere on the board
Cam-MOSI_TX: MOSI.2 (B), TX.2 (B); also elsewhere on the board
Cam-RX: RX.1 (A); also elsewhere on the board
Cam-TX: TX.1 (A); also elsewhere on the board
Cam_SS: SS.1 (A); also elsewhere on the board
GND: 3.3V.1 (K), 5V.1 (K); also elsewhere on the board
MISO: MISO.1 (A); also elsewhere on the board
MOSI: MOSI.1 (A); also elsewhere on the board
unnamed 22: 5V.2 (A); also elsewhere on the board
unnamed 23: 3.3V.2 (A); also elsewhere on the board
unnamed 40: SCK.2 (B); also elsewhere on the board
unnamed 41: SS.2 (B); also elsewhere on the board
SCK: SCK.1 (A); also elsewhere on the board

## KiCad design Schematic-PCB/Dribbler-002-20241225/Dribbler-002-20241225.kicad_pcb

Board: 2 copper layers, 32.3 x 27.8 mm, 8 parts (0 on the bottom side), 9 nets.

Parts:
J3: Conn_01x02_Pin; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
LGC: Signal; LED_0805_2012Metric
PWR: Power; LED_0805_2012Metric
R1, R2: 330; R_0603_1608Metric
SIG/LOGIC: Conn_01x04_Pin; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
U1: DRV8874 module
VIN: Conn_01x02_Pin; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal

Connections:
+3.3V: R1.2, SIG/LOGIC.3, U1.6 (SLEEP)
EN: SIG/LOGIC.2, U1.3 (EN)
GND: LGC.1 (K), PWR.1 (K), SIG/LOGIC.4, U1.2 (GND), U1.5 (PMODE), U1.13 (GND), VIN.2
unnamed: LGC.2 (A), R1.1
unnamed: PWR.2 (A), R2.1
OUT1: J3.1, U1.12 (OUT1)
OUT2: J3.2, U1.11 (OUT2)
PH: SIG/LOGIC.1, U1.4 (PH)
VCC: R2.2, U1.1 (VM), VIN.1
