# Repository nearfactory/2024-TOINIOT2 (continued)

## KiCad design Schematic-PCB/MD-Kicker-20240803/MD-Kicker-20240803.kicad_pcb

Parts:
C1, C2: 4.7u; C_0603_1608Metric
C3, C4: 0.1u; C_0603_1608Metric
C5: 50u; C_0603_1608Metric
C6, C7, C10, C11: 22n; C_0603_1608Metric
C8, C9, C12, C13: 220n; C_0603_1608Metric
C14, C15: 2200uF; CP_Radial_D16.0mm_P7.50mm
C16, C17: 0.33u; C_0603_1608Metric
C18: 0.1uF; C_0603_1608Metric
D1: PWR; LED_0805_2012Metric
D2: SO-5_4.4x3.6mm_P1.27mm
J1: Conn_01x02_Pin; XT30U-M
J2: Conn_01x04_Pin; JST_XH_S4B-XH-A-1_1x04_P2.50mm_Horizontal
J3: Conn_01x15_Pin; TE_1-84953-5_1x15-1MP_P1.0mm_Horizontal
J4, J5, J6, J7: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J8: Conn_01x02_Pin; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
Q1, Q2: NMOS; SOT-23
Q3, Q4: NMOS; TO-252-2
R1, R2, R10, R11: 2.49k; R_0603_1608Metric
R3: 330; R_0603_1608Metric
R4, R6, R12, R13, R14, R15, R16, R18: 10k; R_0603_1608Metric
R5, R7, R17, R19: NP; R_0603_1608Metric; not fitted
R8, R9, R20, R21: 20k; R_0603_1608Metric
R22, R25: 10K; R_0603_1608Metric
R23, R24: 39K; R_0603_1608Metric
U1, U2, U3, U4: HTSSOP-16-1EP_4.4x5mm_P0.65mm_EP3.4x5mm
U5, U6: TSSP58P38; Vishay_MINICAST-3Pin
U7: SOT-23-5
U8: XL6009-SMD

Connections:
+5V: J2.1, R14.1, R15.1
+48V: Q3.2 (D), U8.3 (+OUT)
EN-1: J3.1, U1.1 (EN)
EN-2: J3.3, U3.1 (EN)
EN-3: J3.5, U2.1 (EN)
EN-4: J3.7, U4.1 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C14.2, C15.2, C16.2, C17.2, C18.2, D1.1 (K), D2.3 (Cathode), D2.4 (GND), J1.2, J2.2, J3.15, Q4.3 (S), R1.2, R2.2, R5.2, R7.2, R8.2, R9.2, R10.2, R11.2, R17.2, R19.2, R20.2, R21.2, R22.2, R25.2, U1.9 (PGND), U1.15 (GND), U1.16 (PMODE), U1.17 (GND), U2.9 (PGND), U2.15 (GND), U2.16 (PMODE), U2.17 (GND), U3.9 (PGND), U3.15 (GND), U3.16 (PMODE), U3.17 (GND), U4.9 (PGND), U4.15 (GND), U4.16 (PMODE), U4.17 (GND), U5.2 (GND), U6.2 (GND), U7.3 (GND), U8.2 (-IN), U8.4 (-OUT)
IMODE-1: R8.1, U1.7 (IMODE)
IMODE-2: R20.1, U3.7 (IMODE)
IMODE-3: R9.1, U2.7 (IMODE)
IMODE-4: R21.1, U4.7 (IMODE)
Line-MD-Main=RX_3.3V: J3.12, Q1.3 (S), R12.1
Line-MD-Main=RX_5V: J2.4, Q1.1 (D), R14.2
Line-MD-Main=TX_3.3V: J3.13, Q2.3 (S), R13.1
Line-MD-Main=TX_5V: J2.3, Q2.1 (D), R15.2
unnamed: D1.2 (A), R3.2
unnamed: J8.2, Q4.2 (D)
unnamed: Q4.1 (G), R25.1, U7.4 (OUT)
unnamed: C6.2, U1.13 (CPH)
unnamed: C6.1, U1.14 (CPL)
unnamed: R1.1, U1.6 (IPROPI)
unnamed: C8.1, U1.12 (VCP)
unnamed: C7.2, U2.13 (CPH)
unnamed: C7.1, U2.14 (CPL)
unnamed: R2.1, U2.6 (IPROPI)
unnamed: C9.1, U2.12 (VCP)
unnamed: C10.2, U3.13 (CPH)
unnamed: C10.1, U3.14 (CPL)
unnamed: R10.1, U3.6 (IPROPI)
unnamed: C12.1, U3.12 (VCP)
unnamed: C11.2, U4.13 (CPH)
unnamed: C11.1, U4.14 (CPL)
unnamed: R11.1, U4.6 (IPROPI)
unnamed: C13.1, U4.12 (VCP)
unnamed: R23.1, U5.1 (OUT)
unnamed: R24.1, U6.1 (OUT)
OUT1-1: J4.2, U1.8 (OUT1)
OUT1-2: J5.2, U3.8 (OUT1)
OUT1-3: J6.2, U2.8 (OUT1)
OUT1-4: J7.2, U4.8 (OUT1)
OUT2-1: J4.1, U1.10 (OUT2)
OUT2-2: J5.1, U3.10 (OUT2)
OUT2-3: J6.1, U2.10 (OUT2)
OUT2-4: J7.1, U4.10 (OUT2)
PH-1: J3.2, U1.2 (PH)
PH-2: J3.4, U3.2 (PH)
PH-3: J3.6, U2.2 (PH)
PH-4: J3.8, U4.2 (PH)
SLEEP-1: C18.1, D2.6 (VCC), J3.14, Q1.2 (G), Q2.2 (G), R3.1, R4.1, R6.1, R12.2, R13.2, R16.1, R18.1, U1.3 (SLEEP), U2.3 (SLEEP), U3.3 (SLEEP), U4.3 (SLEEP), U5.3 (Vs), U6.3 (Vs), U7.5 (VCC)
Sig: D2.5 (VO), Q3.1 (G), R22.1, U7.2 (IN)
Sig-main: D2.1 (Anode), J3.10
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C8.2, C9.2, C12.2, C13.2, J1.1, U1.11 (VM), U2.11 (VM), U3.11 (VM), U4.11 (VM), U8.1 (+IN)
VDD: C14.1, C15.1, J8.1, Q3.3 (S)
VREF-1: R4.2, R5.1, U1.5 (VREF)
VREF-2: R16.2, R17.1, U3.5 (VREF)
VREF-3: R6.2, R7.1, U2.5 (VREF)
VREF-4: R18.2, R19.1, U4.5 (VREF)
ball01k: C16.1, J3.9, R23.2
ball02k: C17.1, J3.11, R24.2

Notes on the sheet:
LOW
BallSensor
MD1
Logic-1
POWER
Boost-module
Capacitor
MD2
LEVEL CONVERT
HIGH
Logic-2
TO LINE
MD3
MD4
TO MAIN
TO MOTOR
Photo-Coupler

Board: 2 copper layers, 65 parts (2 on the bottom side), 59 nets, no tracks yet.

## KiCad design Schematic-PCB/Main-002-20241115/Main-002-20241115.kicad_pcb

Parts:
C1, C2: 470uF; CP_Radial_D8.0mm_P3.50mm
C3, C4, C5, C6, C7, C8, C9, C10, C11, C12: 0.1uF; C_0603_1608Metric
C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28: 0.33uF; C_0603_1608Metric
D1: PWR-5; LED_0603_1608Metric
D2: PWR-3.3; LED_0603_1608Metric
D3: D_Small; D_A-405_P7.62mm_Horizontal
J1: Conn_PWR; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J2, J3, J4: Conn_NeoPixel; Connector
J5: CamS3-6; PinSocket_1x06_P2.54mm_Vertical
J6: CamS3-4; NS-Tech_Grove_1x04_P2mm_Vertical
J7: Pixy 2.1; IDC-Header_2x05_P2.54mm_Vertical
J8: Conn_MD; 1.0K-FX-15PWB
J9: Conn_Dribbler; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J10: Conn_UI; JST_XH_B10B-XH-A_1x10_P2.50mm_Vertical
R1, R2: 1K; R_0603_1608Metric
R3, R14, R15: 10K; R_0603_1608Metric
R4, R5: 330; R_0603_1608Metric
R6, R7, R8, R9, R10, R11, R12, R13, R16, R17, R18, R19, R20, R21, R22, R23: 39K; R_0603_1608Metric
RV1: 10K; 3362P
SW1: SW_DPDT_x2; 2MD1-T2-B4-M2-Q-N
SW2: Main_RST; TVBP06-B043C
SW3, SW4: Cam_RST; TVBP06-B043C
U1: DEV-16771; MODULE_DEV-16771
U2: BNO055
U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18: TSSP4038
U19: XIAO ESP32C3

Connections:
3.3V: J1.2, SW1.5 (B), SW1.6 (C)
5.0V: J1.1, SW1.2 (B), SW1.3 (C)
+3.3V: C2.1, C4.1, C6.1, C8.1, C10.1, J8.13, J9.3, J10.1, R1.1, R2.1, R5.1, R14.1, R15.1, RV1.1, SW1.4 (A), U2.1 (VIN), U3.3 (Vs), U4.3 (Vs), U5.3 (Vs), U6.3 (Vs), U7.3 (Vs), U8.3 (Vs), U9.3 (Vs), U10.3 (Vs), U11.3 (Vs), U12.3 (Vs), U13.3 (Vs), U14.3 (Vs), U15.3 (Vs), U16.3 (Vs), U17.3 (Vs), U18.3 (Vs)
+5V: C1.1, C3.1, C5.1, C7.1, C9.1, C11.1, C12.1, D3.2 (A), J2.1, J2.2, J3.1, J3.2, J4.1, J4.2, J5.1, J6.3, J7.2, R4.1, SW1.1 (A), U1.VIN
BUZZER: J10.10, U1.33 (MCLK2)
Cam-RX: J5.3, J6.2, U1.35 (TX8)
Cam-TX: J5.2, J6.1, U1.34 (RX8)
Cam_EN: J5.4, R14.2, SW3.2
Cam_G0: J5.5, R15.2, SW4.2
EN-1: J8.2, U1.2 (OUT2)
EN-2: J8.4, U1.4 (BCLK2)
EN-3: J8.6, U1.6 (OUT1D)
EN-4: J8.8, U1.8 (TX2)
EN-D: J9.2, U19.6 (SCL_D5)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, D1.1 (K), D2.1 (K), J1.3, J2.4, J2.5, J3.3, J3.4, J3.5, J4.3, J4.4, J4.5, J5.6, J6.4, J7.6, J8.1, J9.4, J10.2, RV1.3, SW2.1, SW3.1, SW4.1, U1.GND, U2.2 (GND), U2.7 (GND), U3.2 (GND), U4.2 (GND), U5.2 (GND), U6.2 (GND), U7.2 (GND), U8.2 (GND), U9.2 (GND), U10.2 (GND), U11.2 (GND), U12.2 (GND), U13.2 (GND), U14.2 (GND), U15.2 (GND), U16.2 (GND), U17.2 (GND), U18.2 (GND), U19.13 (GND)
KickerSignal: J8.11, U19.4 (A3_D3)
Line-RX: J8.15, U1.1 (TX1)
Line-TX: J8.14, U1.0 (RX1)
MISO: J7.1, U1.12 (MISO)
MOSI: J7.4, U1.11 (MOSI)
Main-RX7: U1.28 (RX7), U19.7 (TX_D6)
Main-TX7: U1.29 (TX7), U19.8 (RX_D7)
Main_RST: SW2.2, U1.PROGRAM
NeoPixel_PWM: J2.3, U19.11 (MOSI_D10)
unnamed: D1.2 (A), R4.2
unnamed: D2.2 (A), R5.2
unnamed: D3.1 (K), U19.14 (5V)
unnamed: R3.1, RV1.2
unnamed: R6.1, U3.1 (OUT)
unnamed: R7.1, U4.1 (OUT)
unnamed: R8.1, U5.1 (OUT)
unnamed: R9.1, U6.1 (OUT)
unnamed: R10.1, U7.1 (OUT)
unnamed: R11.1, U8.1 (OUT)
unnamed: R12.1, U9.1 (OUT)
unnamed: R13.1, U10.1 (OUT)
unnamed: R16.1, U11.1 (OUT)
unnamed: R17.1, U12.1 (OUT)
unnamed: R18.1, U13.1 (OUT)
unnamed: R19.1, U14.1 (OUT)
unnamed: R20.1, U15.1 (OUT)
unnamed: R21.1, U16.1 (OUT)
unnamed: R22.1, U17.1 (OUT)
unnamed: R23.1, U18.1 (OUT)
PH-1: J8.3, U1.3 (LRCLK2)
PH-2: J8.5, U1.5 (IN2)
PH-3: J8.7, U1.7 (RX2)
PH-4: J8.9, U1.9 (OUT1C)
PH-D: J9.1, U19.5 (SDA_D4)
SCK: J7.3, U1.13 (SCK)
SCL: J10.9, R2.2, U1.24 (A10), U2.4 (SCL/R)
SDA: J10.8, R1.2, U1.25 (A11), U2.3 (SDA/T)
SS: J7.7, U1.10 (CS1)
SW-TAC-1: J10.4, U1.36 (CS2)
SW-TAC-2: J10.5, U1.30 (CRX3)
SW-TAC-3: J10.6, U1.31 (CTX3)
SW-TAC-4: J10.7, U1.32 (OUT1B)
SW-TOG: J10.3, U1.37 (CS3)
Volume: R3.2, U19.3 (A2_D2)
ball01: C13.1, R6.2, U1.14 (A0)
ball01k: J8.10, U19.1 (A0_D0)
ball02: C14.1, R7.2, U1.15 (A1)
ball02k: J8.12, U19.2 (A1_D1)
ball03: C15.1, R8.2, U1.16 (A2)
ball04: C16.1, R9.2, U1.17 (A3)
ball05: C17.1, R10.2, U1.18 (A4)
ball06: C18.1, R11.2, U1.19 (A5)
ball07: C19.1, R12.2, U1.20 (A6)
ball08: C20.1, R13.2, U1.21 (A7)
ball09: C21.1, R16.2, U1.22 (A8)
ball10: C22.1, R17.2, U1.23 (A9)
ball11: C23.1, R18.2, U1.26 (A12)
ball12: C24.1, R19.2, U1.27 (A13)
ball13: C25.1, R20.2, U1.38 (A14)
ball14: C26.1, R21.2, U1.39 (A15)
ball15: C27.1, R22.2, U1.40 (A16)
ball16: C28.1, R23.2, U1.41 (A17)

Notes on the sheet:
ProgramのPCBの足の数を2本に
To NeoPixel1
To Pixy2.1
UART
CamS3に関してはプルアップ必要カモ? おそらくHi-ZとLowの違いで RESETかけている → 誤動作防止用に抵抗付しておく
SUB
NO-プルアップで確認済み 元のモジュール化基板にある ENボタンにもプルアップ抵抗 は確認できなかったためなし
To UI
Teensy4.1
To Dribbler
To CamS3
RESET
To CamS3 Grove
PWR LED
使用前には必ず開発ボード裏の VIN-VUSBジャンパをカットすること USBケーブルとの電源の混合が起き Teensyが燃えるため絶対に!!!!!
To NeoPixel3
Volume
Ball-Sensor | Main
To MD
Power
To NeoPixel2
BNO055
UI ドリブラー MD NeoPixel への ピンアサインは 確認済み 2024.11.02 18.38

Board: 2 copper layers, 88 parts (1 on the bottom side), 77 nets, no tracks yet.

## KiCad design Schematic-PCB/NeoPixel-20240808/NeoPixel-20240808.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16: 0.1uF; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: WS2812B; WS2812B 5.0x5.0mm
J1, J2, J3: Conn_01x05_Pin; Connector

Connections:
+5V: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, D1.1 (VDD), D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), D10.1 (VDD), D11.1 (VDD), D12.1 (VDD), D13.1 (VDD), D14.1 (VDD), D15.1 (VDD), D16.1 (VDD), J1.1, J1.2, J2.1, J2.2, J3.1, J3.2
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, D1.3 (VSS), D2.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), D10.3 (VSS), D11.3 (VSS), D12.3 (VSS), D13.3 (VSS), D14.3 (VSS), D15.3 (VSS), D16.3 (VSS), J1.4, J1.5, J2.3, J2.4, J2.5, J3.3, J3.4, J3.5
NeoPixel_PWM: D1.4 (DIN), J1.3
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D8.2 (DOUT), D9.4 (DIN)
unnamed: D9.2 (DOUT), D10.4 (DIN)
unnamed: D10.2 (DOUT), D11.4 (DIN)
unnamed: D11.2 (DOUT), D12.4 (DIN)
unnamed: D12.2 (DOUT), D13.4 (DIN)
unnamed: D13.2 (DOUT), D14.4 (DIN)
unnamed: D14.2 (DOUT), D15.4 (DIN)
unnamed: D15.2 (DOUT), D16.4 (DIN)

Notes on the sheet:
NEOPIXEL
To Main

Board: 2 copper layers, 112.0 x 112.0 mm, 35 parts (0 on the bottom side), 18 nets.

File Schematic-PCB/NeoPixel-20240808/jlcpcb/production_files/BOM-NeoPixel-20240808.csv:

Comment,Designator,Footprint,LCSC,Quantity
0.1uF,"C1,C10,C11,C12,C13,C14,C15,C16,C2,C3,C4,C5,C6,C7,C8,C9",C_0603_1608Metric,C14663,16
WS2812B,"D1,D10,D11,D12,D13,D14,D15,D16,D2,D3,D4,D5,D6,D7,D8,D9",WS2812B 5.0x5.0mm,C2843785,16
