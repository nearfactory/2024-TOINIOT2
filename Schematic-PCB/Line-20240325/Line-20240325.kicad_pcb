# Repository nearfactory/2024-TOINIOT2

## KiCad design Schematic-PCB/Line-20240325/Line-20240325.kicad_pcb

Parts:
BZ1: Buzzer; PKM13EPYH4000-A0
C1: 100uF; CP_Radial_D10.0mm_P5.00mm
C2, C3, C4: 0.1uF; C_0603_1608Metric
Comp1, Comp2, Comp3, Comp4, Comp5, Comp6, Comp7, Comp8, Comp9, Comp10, Comp11, Comp12: LM339
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46: LED_Small; LED-3mm
D47: LED01; LED_0603_1608Metric
D48: LED02; LED_0603_1608Metric
D49: LED03; LED_0603_1608Metric
D50: POWER; LED_0603_1608Metric
J1: Conn_PWR; JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical
J2: Conn_MD; JST_XH_S4B-XH-A-1_1x04_P2.50mm_Horizontal
Q1: NMOS 60V-5A; TO-252-2
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46: 75; R_0603_1608Metric
R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R76, R77, R78, R79, R80, R81, R82, R83, R84, R85, R86, R87, R88, R89, R90, R91, R92: Line-Pulldown; R_0603_1608Metric
R93, R94, R95, R96: 330; R_0603_1608Metric
R97: 1K; R_0603_1608Metric
R98: 10K; R_0603_1608Metric
SW1: SW_LED
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19, U20, U21, U22, U23, U24, U25, U26, U27, U28, U29, U30, U31, U32, U33, U34, U35, U36, U37, U38, U39, U40, U41, U42, U43, U44, U45, U46: NJL7502L
U47: MEGA_PRO_EMBED_CH340G___ATMEGA2560; ATmega2560Pro Board; PARTREV 12/May/2017

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, Comp1.3 (VCC), Comp2.3 (VCC), Comp3.3 (VCC), Comp4.3 (VCC), Comp5.3 (VCC), Comp6.3 (VCC), Comp7.3 (VCC), Comp8.3 (VCC), Comp9.3 (VCC), Comp10.3 (VCC), Comp11.3 (VCC), Comp12.3 (VCC), J1.1, J2.1, Q1.1 (D), R96.1, R97.1, U1.2 (Collector), U2.2 (Collector), U3.2 (Collector), U4.2 (Collector), U5.2 (Collector), U6.2 (Collector), U7.2 (Collector), U8.2 (Collector), U9.2 (Collector), U10.2 (Collector), U11.2 (Collector), U12.2 (Collector), U13.2 (Collector), U14.2 (Collector), U15.2 (Collector), U16.2 (Collector), U17.2 (Collector), U18.2 (Collector), U19.2 (Collector), U20.2 (Collector), U21.2 (Collector), U22.2 (Collector), U23.2 (Collector), U24.2 (Collector), U25.2 (Collector), U26.2 (Collector), U27.2 (Collector), U28.2 (Collector), U29.2 (Collector), U30.2 (Collector), U31.2 (Collector), U32.2 (Collector), U33.2 (Collector), U34.2 (Collector), U35.2 (Collector), U36.2 (Collector), U37.2 (Collector), U38.2 (Collector), U39.2 (Collector), U40.2 (Collector), U41.2 (Collector), U42.2 (Collector), U43.2 (Collector), U44.2 (Collector), U45.2 (Collector), U46.2 (Collector), U47.5V
Buzzer: BZ1.1 (+), U47.D3
GND: BZ1.2 (-), C1.2, C2.2, C3.2, C4.2, Comp1.12 (GND), Comp2.12 (GND), Comp3.12 (GND), Comp4.12 (GND), Comp5.12 (GND), Comp6.12 (GND), Comp7.12 (GND), Comp8.12 (GND), Comp9.12 (GND), Comp10.12 (GND), Comp11.12 (GND), Comp12.12 (GND), D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), J1.2, J2.2, R47.2, R48.2, R49.2, R50.2, R51.2, R52.2, R53.2, R54.2, R55.2, R56.2, R57.2, R58.2, R59.2, R60.2, R61.2, R62.2, R63.2, R64.2, R65.2, R66.2, R67.2, R68.2, R69.2, R70.2, R71.2, R72.2, R73.2, R74.2, R75.2, R76.2, R77.2, R78.2, R79.2, R80.2, R81.2, R82.2, R83.2, R84.2, R85.2, R86.2, R87.2, R88.2, R89.2, R90.2, R91.2, R92.2, R98.1, U47.GND
LED01: R93.1, U47.D4
LED02: R94.1, U47.D5
LED03: R95.1, U47.D6
LED_5V: Q1.3 (S), R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, R40.2, R41.2, R42.2, R43.2, R44.2, R45.2, R46.2
Line01: Comp2.14 (3OUT), U47.D7
Line02: Comp1.14 (3OUT), U47.D8
Line03: Comp1.13 (4OUT), U47.D9
Line04: Comp1.1 (1OUT), U47.D10
Line05: Comp1.2 (2OUT), U47.D11
Line06: Comp5.14 (3OUT), U47.D12
Line07: Comp5.13 (4OUT), U47.D13
Line08: Comp4.13 (4OUT), U47.D14
Line09: Comp5.2 (2OUT), U47.D15
Line10: Comp4.14 (3OUT), U47.D16
Line11: Comp9.13 (4OUT), U47.D17
Line12: Comp9.14 (3OUT), U47.D18
Line13: Comp9.1 (1OUT), U47.D19
Line14: Comp8.2 (2OUT), U47.D20
Line15: Comp7.14 (3OUT), U47.D21
Line16: Comp7.1 (1OUT), U47.D22
Line17: Comp7.2 (2OUT), U47.D23
Line18: Comp12.13 (4OUT), U47.D24
Line19: Comp12.14 (3OUT), U47.D25
Line20: Comp12.1 (1OUT), U47.D26
Line21: Comp10.14 (3OUT), U47.D27
Line22: Comp10.13 (4OUT), U47.D28
Line23: Comp10.1 (1OUT), U47.D29
Line24: Comp10.2 (2OUT), U47.D30
Line25: Comp3.13 (4OUT), U47.D31
Line26: Comp3.14 (3OUT), U47.D32
Line27: Comp3.1 (1OUT), U47.D33
Line28: Comp3.2 (2OUT), U47.D34
Line29: Comp2.13 (4OUT), U47.D35
Line30: Comp2.1 (1OUT), U47.D36
Line31: Comp2.2 (2OUT), U47.D37
Line32: Comp6.14 (3OUT), U47.D38
Line33: Comp6.1 (1OUT), U47.D39
Line34: Comp6.2 (2OUT), U47.D40
Line35: Comp6.13 (4OUT), U47.D41
Line36: Comp5.1 (1OUT), U47.D42
Line37: Comp9.2 (2OUT), U47.D43
Line38: Comp8.13 (4OUT), U47.D44
Line39: Comp8.14 (3OUT), U47.D45
Line40: Comp8.1 (1OUT), U47.D46
Line41: Comp7.13 (4OUT), U47.D47
Line42: Comp12.2 (2OUT), U47.D48
Line43: Comp11.13 (4OUT), U47.D49
Line44: Comp11.14 (3OUT), U47.D50
Line45: Comp11.1 (1OUT), U47.D51
Line46: Comp11.2 (2OUT), U47.D52
Line-Main=RX_5V: J2.4
Line-Main=TX_5V: J2.3
LineThreshold: Comp1.4 (2IN-), Comp1.6 (1IN-), Comp1.8 (3IN-), Comp1.10 (4IN-), Comp2.4 (2IN-), Comp2.6 (1IN-), Comp2.8 (3IN-), Comp2.10 (4IN-), Comp3.4 (2IN-), Comp3.6 (1IN-), Comp3.8 (3IN-), Comp3.10 (4IN-), Comp4.8 (3IN-), Comp4.10 (4IN-), Comp5.4 (2IN-), Comp5.6 (1IN-), Comp5.8 (3IN-), Comp5.10 (4IN-), Comp6.4 (2IN-), Comp6.6 (1IN-), Comp6.8 (3IN-), Comp6.10 (4IN-), Comp7.4 (2IN-), Comp7.6 (1IN-), Comp7.8 (3IN-), Comp7.10 (4IN-), Comp8.4 (2IN-), Comp8.6 (1IN-), Comp8.8 (3IN-), Comp8.10 (4IN-), Comp9.4 (2IN-), Comp9.6 (1IN-), Comp9.8 (3IN-), Comp9.10 (4IN-), Comp10.4 (2IN-), Comp10.6 (1IN-), Comp10.8 (3IN-), Comp10.10 (4IN-), Comp11.4 (2IN-), Comp11.6 (1IN-), Comp11.8 (3IN-), Comp11.10 (4IN-), Comp12.4 (2IN-), Comp12.6 (1IN-), Comp12.8 (3IN-), Comp12.10 (4IN-)
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R3.1
unnamed: D4.2 (A), R4.1
unnamed: D5.2 (A), R5.1
unnamed: D6.2 (A), R6.1
unnamed: D7.2 (A), R7.1
unnamed: D8.2 (A), R8.1
unnamed: D9.2 (A), R9.1
unnamed: D10.2 (A), R10.1
unnamed: D11.2 (A), R11.1
unnamed: D12.2 (A), R12.1
unnamed: D13.2 (A), R13.1
unnamed: D14.2 (A), R14.1
unnamed: D15.2 (A), R15.1
unnamed: D16.2 (A), R16.1
unnamed: D17.2 (A), R17.1
unnamed: D18.2 (A), R18.1
unnamed: D19.2 (A), R19.1
unnamed: D20.2 (A), R20.1
unnamed: D21.2 (A), R21.1
unnamed: D22.2 (A), R22.1
unnamed: D23.2 (A), R23.1
unnamed: D24.2 (A), R24.1
unnamed: D25.2 (A), R25.1
unnamed: D26.2 (A), R26.1
unnamed: D27.2 (A), R27.1
unnamed: D28.2 (A), R28.1
unnamed: D29.2 (A), R29.1
unnamed: D30.2 (A), R30.1
unnamed: D31.2 (A), R31.1
unnamed: D32.2 (A), R32.1
unnamed: D33.2 (A), R33.1
unnamed: D34.2 (A), R34.1
unnamed: D35.2 (A), R35.1
unnamed: D36.2 (A), R36.1
unnamed: D37.2 (A), R37.1
unnamed: D38.2 (A), R38.1
unnamed: D39.2 (A), R39.1
unnamed: D40.2 (A), R40.1
unnamed: D41.2 (A), R41.1
unnamed: D42.2 (A), R42.1
unnamed: D43.2 (A), R43.1
unnamed: D44.2 (A), R44.1
unnamed: D45.2 (A), R45.1
unnamed: D46.2 (A), R46.1
unnamed: D47.2 (A), R93.2
unnamed: D48.2 (A), R94.2
unnamed: D49.2 (A), R95.2
unnamed: D50.2 (A), R96.2
unnamed: Q1.2 (G), R98.2, SW1.1 (A)
unnamed: R97.2, SW1.2 (B)
RST: U47.RST
Raw01: Comp2.9 (3IN+), R47.1, U1.1 (Emitter), U47.A0
Raw02: Comp1.9 (3IN+), R48.1, U2.1 (Emitter)
Raw03: Comp1.11 (4IN+), R49.1, U3.1 (Emitter)
Raw04: Comp1.7 (1IN+), R50.1, U4.1 (Emitter)
Raw05: Comp1.5 (2IN+), R51.1, U5.1 (Emitter), U47.A1
Raw06: Comp5.9 (3IN+), R52.1, U6.1 (Emitter)
Raw07: Comp5.11 (4IN+), R53.1, U7.1 (Emitter)
Raw08: Comp4.11 (4IN+), R54.1, U8.1 (Emitter)
Raw09: Comp5.5 (2IN+), R55.1, U9.1 (Emitter), U47.A2
Raw10: Comp4.9 (3IN+), R56.1, U10.1 (Emitter)
Raw11: Comp9.11 (4IN+), R57.1, U11.1 (Emitter)
Raw12: Comp9.9 (3IN+), R58.1, U12.1 (Emitter)
Raw13: Comp9.7 (1IN+), R59.1, U13.1 (Emitter), U47.A3
Raw14: Comp8.5 (2IN+), R60.1, U14.1 (Emitter)
Raw15: Comp7.9 (3IN+), R61.1, U15.1 (Emitter)
Raw16: Comp7.7 (1IN+), R62.1, U16.1 (Emitter)
Raw17: Comp7.5 (2IN+), R63.1, U17.1 (Emitter), U47.A4
Raw18: Comp12.11 (4IN+), R64.1, U18.1 (Emitter)
Raw19: Comp12.9 (3IN+), R65.1, U19.1 (Emitter)
Raw20: Comp12.7 (1IN+), R66.1, U20.1 (Emitter)
Raw21: Comp10.9 (3IN+), R67.1, U21.1 (Emitter), U47.A5
Raw22: Comp10.11 (4IN+), R68.1, U22.1 (Emitter)
Raw23: Comp10.7 (1IN+), R69.1, U23.1 (Emitter)
Raw24: Comp10.5 (2IN+), R70.1, U24.1 (Emitter)
Raw25: Comp3.11 (4IN+), R71.1, U25.1 (Emitter), U47.A6
Raw26: Comp3.9 (3IN+), R72.1, U26.1 (Emitter)
Raw27: Comp3.7 (1IN+), R73.1, U27.1 (Emitter)
Raw28: Comp3.5 (2IN+), R74.1, U28.1 (Emitter)
Raw29: Comp2.11 (4IN+), R75.1, U29.1 (Emitter), U47.A7
Raw30: Comp2.7 (1IN+), R76.1, U30.1 (Emitter)
Raw31: Comp2.5 (2IN+), R77.1, U31.1 (Emitter)
Raw32: Comp6.9 (3IN+), R78.1, U32.1 (Emitter)
Raw33: Comp6.7 (1IN+), R79.1, U33.1 (Emitter), U47.A8
Raw34: Comp6.5 (2IN+), R80.1, U34.1 (Emitter)
Raw35: Comp6.11 (4IN+), R81.1, U35.1 (Emitter)
Raw36: Comp5.7 (1IN+), R82.1, U36.1 (Emitter)
Raw37: Comp9.5 (2IN+), R83.1, U37.1 (Emitter), U47.A9
Raw38: Comp8.11 (4IN+), R84.1, U38.1 (Emitter)
Raw39: Comp8.9 (3IN+), R85.1, U39.1 (Emitter)
Raw40: Comp8.7 (1IN+), R86.1, U40.1 (Emitter)
Raw41: Comp7.11 (4IN+), R87.1, U41.1 (Emitter), U47.A10
Raw42: Comp12.5 (2IN+), R88.1, U42.1 (Emitter)
Raw43: Comp11.11 (4IN+), R89.1, U43.1 (Emitter)
Raw44: Comp11.9 (3IN+), R90.1, U44.1 (Emitter)
Raw45: Comp11.7 (1IN+), R91.1, U45.1 (Emitter), U47.A11
Raw46: Comp11.5 (2IN+), R92.1, U46.1 (Emitter)
Threshold: U47.D2

Notes on the sheet:
MPU-Buzzer
Photo-Transistor
照度センサのプルダウン用の抵抗値→だいたい10KΩ-20KΩが適正 プルダウンが無いとセンサの出力がずっとHIGHに張り付いてしまう
Comparator
MPU-LED
Power
LED
To MD
LED Switch

Board: 4 copper layers, 195.0 x 192.8 mm, 215 parts (196 on the bottom side), 151 nets.

## KiCad design Schematic-PCB/Line-ATmega2560-20240913/Line-ATmega2560-20240913.kicad_pcb

Board: 2 copper layers, 39.0 x 32.0 mm, 25 parts (0 on the bottom side), 21 nets.

Parts:
C1, C3, C4, C5, C6: 100n; C_0603_1608Metric
C2: 22p; C_0603_1608Metric
D1: POWER; LED_0603_1608Metric
D2, D3, D4: LED1; LED_0603_1608Metric
J8: CH340E; PinSocket_1x06_P2.54mm_Vertical
J9: ICSP; PinSocket_2x03_P2.54mm_Vertical
J10: VIN; PinSocket_1x02_P2.54mm_Vertical
R1, R3, R4, R8: 330; R_0603_1608Metric
R2, R5, R6: 10K; R_0603_1608Metric
R7: 27; R_0603_1608Metric
R9: 1M; R_0603_1608Metric
SW1: SW_Push; Tactile1
U1: ATmega2560-16A; TQFP-100_14x14mm_P0.5mm
Y1: 16MHz; Resonator_Murata_CSTLSxxxX-3Pin_W5.5mm_H3.0mm

Connections:
+5V: C3.1, C4.1, C5.1, C6.1, J9.2, J10.1, R1.1, R2.1, R5.1, R6.1, U1.10 (VCC), U1.31 (VCC), U1.61 (VCC), U1.80 (VCC), U1.100 (AVCC)
D2: R3.1, U1.6 (PE4/D2)
D3: R4.1, U1.7 (PE5/D3)
D13: R8.1, U1.26 (PB7/D13)
D50_MISO: J9.1, U1.22 (PB3/D50/MISO)
D51_MOSI: J9.4, U1.21 (PB2/D51/MOSI)
D52_SCK: J9.3, U1.20 (PB1/D52/SCK)
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), J8.6, J9.6, J10.2, SW1.2, U1.11 (GND), U1.32 (GND), U1.62 (GND), U1.81 (GND), U1.99 (GND), Y1.2
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R3.2
unnamed: D3.2 (A), R4.2
unnamed: D4.2 (A), R8.2
unnamed: R7.2, Y1.1
unnamed: C1.2, U1.98 (AREF)
RESET: C2.1, J8.1, J9.5, R2.2, SW1.1, U1.30 (~RESET)
RX0: J8.3, U1.2 (PE0/D0/RX0)
SCL: R5.2, U1.43 (PD0/D21/SCL)
SDA: R6.2, U1.44 (PD1/D20/SDA)
TX0: J8.2, U1.3 (PE1/D1/TX0)
XTAL1: R7.1, R9.1, U1.34 (XTAL1)
XTAL2: R9.2, U1.33 (XTAL2), Y1.3

## KiCad design Schematic-PCB/M5StackCam-20240924/M5StackCam-20240924.kicad_pcb

Parts:
J1: Conn_CamL; PinHeader_1x03_P2.54mm_Vertical
J2: Conn_CamR; PinHeader_1x03_P2.54mm_Vertical
J3: Conn_Output; PinHeader_1x06_P2.54mm_Horizontal

Connections:
+5V: J2.3, J3.1
EN: J1.1, J3.4
G0: J1.2, J3.5
GND: J1.3, J3.6
RX: J2.1, J3.3
TX: J2.2, J3.2

Board: 2 copper layers, 20.3 x 15.7 mm, 3 parts (3 on the bottom side), 6 nets.
